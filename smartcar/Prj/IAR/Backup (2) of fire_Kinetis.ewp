# IAR project Backup (2) of fire_Kinetis.ewp, settings and files
configuration FX15_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: IAR; DEBUG; MK60DZ10; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_Kinetis.hex
  ILINK.IlinkOutputFile: fire_Kinetis.out
  ILINK.IlinkIcfFile: F:\code\SmartCar_freescale\smartcar\Prj\IAR\config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FX15_Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: E:\TEST\SmartCar_freescale7\smartcar\Prj\IAR\config files\fire_ROM_K60N512.icf
configuration DZ10_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: angle.c camera.c display.c init.c main.c MK60_it.c motor.c variable.c
  group App/H
    ../../App/Inc/: angle.h camera.h display.h include.h init.h MK60_it.h motor.h variable.h
    ../../Chip/inc/: common.h
  group Board
    ../../Board/src/: DMA_OV7620.c FIRE_key.c FIRE_LED.C FIRE_MK60_conf.c FIRE_MMA7455.c FIRE_NRF24L0.c FIRE_RTC_count.C OLED12864.c sccb.c
  group board_header
    ../../Board/inc/: DMA_OV7620.h FIRE_key.h FIRE_LED.H FIRE_MK60_conf.h FIRE_MMA7455.h FIRE_NRF24L0.h FIRE_PORT_cfg.h FIRE_RTC_count.h oled12864.h sccb.h
  group Chip
    ../../Chip/src/: delay.c exti.c misc.c MK60_adc.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group chip_header
    ../../Chip/inc/: delay.h exti.h misc.h MK60_adc.h MK60_DWT.h MK60_flash.h MK60_FTM.h MK60_gpio.h MK60_gpio_cfg.h MK60_i2c.h MK60_lptmr.h MK60_mcg.h MK60_PIT.h MK60_port.h MK60_rtc.h MK60_spi.h MK60_SysTick.h MK60_uart.h MK60_wdog.h vectors.h
  group LIB/CMSIS
    ../../Lib/CMSIS/: iar_cortexM4l_math.a
