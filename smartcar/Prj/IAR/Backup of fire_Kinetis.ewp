# IAR project Backup of fire_Kinetis.ewp, settings and files
configuration FX15_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: IAR; DEBUG; ARM_MATH_CM4; MK60F15
  ICCARM.CCIncludePath2: ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_Kinetis.hex
  ILINK.IlinkOutputFile: fire_Kinetis.out
  ILINK.IlinkIcfFile: config files\fire_RAM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FX15_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  ICCARM.CCDefines: NDEBUG; IAR; ARM_MATH_CM4; MK60F15
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config files\fire_ROM_K60N512.icf
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; DEBUG; MK60DZ10; ARM_MATH_CM4
  ILINK.IlinkIcfFile: E:\TEST\SmartCar_freescale\smartcar\Prj\IAR\config files\fire_ROM_K60N512.icf
configuration DZ10_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config files\fire_ROM_K60N512.icf
  group App
    ../../App/: angle.c display.c init.c main.c MK60_it.c variable.c
    ../../App/Inc/: angle.h display.h include.h variable.h
    ../../Chip/inc/: common.h
  group Board
    ../../Board/src/: FIRE_key.c FIRE_LED.C FIRE_MK60_conf.c FIRE_MMA7455.c FIRE_NRF24L0.c FIRE_RTC_count.C OLED12864.c
    ../../Board/inc/: FIRE_MK60_conf.h
  group board_header
    ../../Board/inc/: FIRE_key.h FIRE_LED.H FIRE_MMA7455.h FIRE_NRF24L0.h FIRE_PORT_cfg.h FIRE_RTC_count.h oled12864.h
  group Chip
    ../../Chip/src/: delay.c misc.c MK60_adc.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group chip_header
    ../../Chip/inc/: delay.h misc.h MK60_adc.h MK60_DWT.h MK60_FLASH.h MK60_FTM.h MK60_gpio.h MK60_gpio_cfg.h MK60_i2c.h MK60_lptmr.h MK60_mcg.h MK60_PIT.h MK60_port.h MK60_rtc.h MK60_spi.h MK60_SysTick.h MK60_uart.h MK60_wdog.h vectors.h
  group LIB/CMSIS
    ../../Lib/CMSIS/: iar_cortexM4l_math.a
